# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System;.\User;.\App;.\Control
  group User
    ./User/: main.c
  group System
    ./System/: Uart.c GPIO.c Timer0.c Wdt.c Public_cfg.c i2c_bus.c Uart2.c
  group Hardware
    ./Hardware/: tcs3400_driver.c modbus_uart2.c
  group App
    ./App/: tcs3400_app.c pressure_sensor_app.c
  group Control
    ./Control/: action_control.c
